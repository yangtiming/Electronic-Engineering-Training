# Keil uVision project smartcars.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x0EFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: smartcars +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c LCD12864.c Delay.c Delay.h stc15w4k58s4.h motor.c uart.c sonic.c infrared.c
